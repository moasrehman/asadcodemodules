# Keil uVision project FreeRTOS_application_4.uvprojx, settings and files
target STM32F103 Flash (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FreeRTOS_LED_Toggle
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Files
    ./: RTX_Blinky.c check_traffic_light.c change_traffic_light.c RTX_Blinky.h change_traffic_light.h check_traffic_light.h
  group Documentation
    ./: README.txt
target STM32F103 RAM (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: RTX_Blinky
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x20004000 size 0x1000
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
